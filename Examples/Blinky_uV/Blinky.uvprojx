# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6220000::V6.22::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.19.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\RTE\Device\MCXN947VDF_cm33_core0\MCXN947_cm33_core0_flash.scf
  group App
    ./: Blinky.c
  group Board
    ./: main.c main.h retarget_stdio.c vio_FRDM-MCXN947.c
software components: CMSIS Driver:VIO:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:MCXN947_header 1.0.0, Device:CMSIS:MCXN947_system 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.4.1, Device:SDK Drivers:gpio 2.7.3, Device:SDK Drivers:lpflexcomm 2.2.1, Device:SDK Drivers:lpuart 2.3.2, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:mcx_spc 2.4.2, Device:SDK Drivers:port 2.5.0, Device:SDK Drivers:reset 2.1.2, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:str 1.0.0, Device:Startup 1.1.0
